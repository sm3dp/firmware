# Keil uVision project BH-F407.uvprojx, settings and files
target SM3D (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SM3DP +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\..\Bin\SM3DP.bin  ..\..\Output\SM3DP.axf
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c misc: --diag_suppress=1035,167 --locale=english
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Driver;..\..\User;..\..\APP;..\..\FATFS\src;..\..\FATFS\exfuns;..\..\Hardware\24CXX;..\..\Hardware\PWMOUTPUT;..\..\Hardware\SD;..\..\Hardware\SWITCH;..\..\Hardware\WATCHDOG;..\..\Step_motor;..\..\Thermistor;..\..\Malloc;..\..\Hardware\TOUCH;..\..\Text;..\..\Picture;..\..\Gui;..\..\Hardware\LCD;..\..\quicklz;..\..\Hardware\STMFLASH;..\..\SM;..\..\Hardware\SPIFLASH;..\..\qrencode;..\..\Hardware\SD_2;..\..\Hardware\SD_SPI;..\..\Hardware\SD;..\..\Hardware\SDIO;..\..\Hardware\RNG;..\..\Hardware\KimHD;..\..\Hardware\LSAER
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c
    ../../Hardware/LSAER/: laser.c
  group DOC
    ../../: 必读说明.txt
  group Driver
    ../../Driver/: stm32f4xx_it.c usart.c Bsp.c delay.c sys.c iic.c
    ../../Hardware/24CXX/: 24cxx.c
    ../../Hardware/WATCHDOG/: watchdog.c
    ../../Hardware/SDIO/: sdio_sdcard.c
    ../../Hardware/TOUCH/: touch.c
    ../../Hardware/STMFLASH/: stmflash.c
    ../../Hardware/LCD/: lcd.c
    ../../Hardware/SPIFLASH/: bsp_spi_flash.c
    ../../Hardware/SD_2/: MMC_SD.C
    ../../Hardware/SD_SPI/: sd_spi.c
  group Malloc
    ../../Malloc/: malloc.c
  group Fatfs
    ../../FATFS/exfuns/: exfuns.c
    ../../FATFS/src/: diskio.c ff.c
    ../../FATFS/src/option/: cc936.c
  group Step_motor
    ../../Step_motor/: stepper.c
  group Themistor
    ../../Thermistor/: temperature.c
  group App
    ../../APP/: gcodeplayer.c sm_plus.c
  group SM_FIRMWARE
    ../../SM/: ConfigurationStore.c motion_control.c planner.c sm_firmware.c
  group Picture
    ../../Picture/: bmp.c gif.c piclib.c tjpgd.c
  group Gui
    ../../Gui/: button.c filelistbox.c gui.c scrollbar.c lcd_menu.c
  group Text
    ../../Text/: text.c
  group KimHD
    ../../Hardware/KimHD/: App_ADC.c App_InfShow.c App_SystemPortConfig.c App_Timer.c
